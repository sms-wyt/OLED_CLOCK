# IAR project Graphics.ewp, settings and files
configuration Graphics (8051, debug)
  General.OGChipSelectMenu: STC8A8K64S4A12 STC8A8K64S4A12
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\Components\board\include; ..\..\Components\driver\include; ..\..\Components\device\include; source
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\STC\lnk51ew_STC8A8K64S4A12.xcl
  group app
    source/: main.c
  group Device
    ../../Components/device/common/: clock_plate.c ds3231.c oled.c
  group Driver
    ../../Components/driver/common/: delay.c i2c_hard.c spi_hard.c uart.c
